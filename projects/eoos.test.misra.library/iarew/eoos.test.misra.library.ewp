# IAR project eoos.test.misra.library.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: EOOS_TYPE_WIDTH_LP64; NO_STRICT_MISRA_RULES
  ICCARM.CCIncludePath2: D:\baigudin\git\baigudin\eoos-library\include; D:\baigudin\git\baigudin\eoos-api\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../source/: Allocator.cpp Program.library.cpp
    ../source/: main.cpp
