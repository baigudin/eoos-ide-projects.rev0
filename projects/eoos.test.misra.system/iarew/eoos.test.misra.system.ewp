# IAR project eoos.test.misra.system.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NO_STRICT_MISRA_RULES
  ICCARM.CCIncludePath2: D:\baigudin\git\baigudin\eoos\api\include; D:\baigudin\git\baigudin\eoos\system\include; D:\baigudin\git\baigudin\eoos\library\include; D:\baigudin\git\baigudin\eoos\cpu\ti\tms320c64xplus\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: eoos.test.misra.system.srec
  ILINK.IlinkOutputFile: eoos.test.misra.system.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Codebase
    ../../eoos.exe.ti.tms320c64xplus/source/: Allocator.cpp Configuration.cpp
    ../../../../cpu/ti/tms320c64xplus/source/: cpu.Allocator.cpp cpu.Boot.cpp cpu.Cpu.cpp cpu.Object.cpp
    ../../../source/: Program.cpp
    ../../../../system/source/: system.Allocator.cpp system.Kernel.cpp system.Object.cpp system.System.cpp
